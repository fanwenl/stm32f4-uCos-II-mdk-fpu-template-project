# Keil uVision project stm32f4-uCos-II-project.uvproj, settings and files
target stm32f4-uCos-II (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4-uCos-II-project +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Drivers;..\Modules;..\uCos-II\port;..\uCos-II\source;..\User;..\Apps
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/: startup_stm32f40xx.s system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Drivers
    ../Drivers/: gpio.c usart.c
  group Modules
    ../Modules/: stm32f4_discovery.c
  group Apps
    ../Apps/: apps.c
  group User
    ../User/: main.c stm32f4xx_it.c util.c
  group uCos/port
    ../uCos-II/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg_r.c
  group uCos/source
    ../uCos-II/source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group Doc
    ../Doc/: readme.txt
